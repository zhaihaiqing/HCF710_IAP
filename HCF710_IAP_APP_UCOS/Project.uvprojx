# Keil uVision project Project.uvprojx, settings and files
target STM32L1xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Output\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX
  c include: .\User;.\FWlib\src;.\FWlib\inc;.\CMSIS;.\HW_driver;.\UCOS_III\uC-CPU;.\UCOS_III\uC-LIB;.\UCOS_III\uCOS-III;.\UCOS_III\uC-BSP;.\UCOS_III\uC-CONFIG;.\UCOS_III\uCOS-III\Source;.\UCOS_III\uC-CPU\ARM-Cortex-M3\RealView;.\UCOS_III\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOS_III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: main.c stm32l1xx_it.c Modbus.c PAS.c Temp.c
  group HW_driver
    ./HW_driver/: gpio.c SPI.c uart.c IEEPROM.c IADC.c Timer.c
  group StdPeriph_Driver
    ./FWlib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ./HW_driver/: system_stm32l1xx.c
  group MDK-ARM
    ./CMSIS/startup/arm/: startup_stm32l1xx_md.s
  group UCOSIII_BSP
    ./UCOS_III/uC-BSP/: bsp.c bsp.h bsp_os.c bsp_os.h bsp_periph.c cstartup.s bsp_int.c
  group UCOSIII_CORE
    ./UCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_CONFIG
    ./UCOS_III/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII_CPU
    ./UCOS_III/uC-CPU/: cpu_core.c
    ./UCOS_III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ./UCOS_III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOS_III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_PORT
    ./UCOS_III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Doc
    ./Doc/: Version.txt
